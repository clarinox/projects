<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>clarinox_wifi_bluetooth</project>
        <configuration>flash_release</configuration>
      </member>
      <member>
        <project>clarinox_wifi_bluetooth</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>clarinox_wifi_bluetooth</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>clarinox_wifi_bluetooth</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/clarinox_wifi_bluetooth.ewp</path>
  </project>
</workspace>
