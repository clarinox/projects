# IAR project clarinox_wifi_bluetooth.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; USE_RTODEBUG; USE_RTOS=1; CONFIG_MONOLITHIC_WIFI=0; PRINTF_ADVANCED_ENABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; CONFIG_WIFI_IND_DNLD=1; CONFIG_WIFI_IND_RESET=1; WIFI_BOARD_FRDM_RW61X; GENERIC_LIST_LIGHT=1; MFLASH_FILE_BASEADDR=7340032; CONFIG_NXP_WIFI_SOFTAP_SUPPORT=1; PRINTF_FLOAT_ENABLE=1; SO_REUSE=1; SDK_OS_FREE_RTOS; CLX_DEBUG; CLX_ARM; CLX_IAR; CLX_FREE_RTOS; CLX_LITTLE_ENDIAN; CLX_88W8977; CLX_64BIT_SUPPORT; __CLX_SOCKETS_SUPPORT; CLX_BSP_TEST=0; READ_ONLY_FILE_SUPPORTED; CLX_WPA_SUPPLICANT; CLX_WLAN_HOST_AP; CLX_IEEE802_11_N_SUPPORTED; CLX_IEEE802_11_R_SUPPORTED; CLX_USE_UART_FOR_CLARIFI_CONNECTION; __CLX_RW612_NXP_BOARD; __CLX_RW612_UBLOX_BOARD; CLX_RW612_FRDM_BOARD; __CLX_RW612_ISP_BOARD; __CLX_RW612_MURATA_BOARD; CLX_WLAN_VIRTUAL_AP_SUPPORTED; CLX_MARVELL; __CLARINOX_WLAN_MESH_SUPPORTED; CLX_NETWORK_INTERFACE_LWIP; CLX_ENABLE_BLUETOOTH; CLX_BLE_CENTRAL; CLX_BLE_PERIPHERAL; __CLX_BLE_ISOCHRONOUS; __CLX_WIFI_MESH_AUTO; __CLARINOX_WLAN_MESH_TOPOLOGY_TREE_SUPPORTED; CLX_BLE_HIGH_QUALITY_AUDIO; __CLX_BANDWIDTH_LIMIT_SUPPORTED; __CLARINOX_MESH_DEMO_ROOT_MENU; __CLARINOX_MESH_DEMO_NONROOT_MENU; USE_CLARINOX_POOLSETS=1; CONFIG_MONOLITHIC_WIFI=0; PRINTF_ADVANCED_ENABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; CONFIG_WIFI_IND_DNLD=1; CONFIG_WIFI_IND_RESET=1; WIFI_BOARD_FRDM_RW61X; GENERIC_LIST_LIGHT=1; MFLASH_FILE_BASEADDR=7340032; CONFIG_NXP_WIFI_SOFTAP_SUPPORT=1; PRINTF_FLOAT_ENABLE=1; SO_REUSE=1; SDK_OS_FREE_RTOS; CLX_DEBUG; CLX_ARM; CLX_IAR; CLX_FREE_RTOS; CLX_LITTLE_ENDIAN; CLX_88W8977; CLX_64BIT_SUPPORT; __CLX_SOCKETS_SUPPORT; CLX_BSP_TEST=0; READ_ONLY_FILE_SUPPORTED; CLX_WPA_SUPPLICANT; CLX_WLAN_HOST_AP; CLX_IEEE802_11_N_SUPPORTED; CLX_IEEE802_11_R_SUPPORTED; CLX_USE_UART_FOR_CLARIFI_CONNECTION; __CLX_RW612_NXP_BOARD; __CLX_RW612_UBLOX_BOARD; CLX_RW612_FRDM_BOARD; __CLX_RW612_ISP_BOARD; __CLX_RW612_MURATA_BOARD; CLX_WLAN_VIRTUAL_AP_SUPPORTED; CLX_MARVELL; __CLARINOX_WLAN_MESH_SUPPORTED; CLX_NETWORK_INTERFACE_LWIP; CLX_ENABLE_BLUETOOTH; CLX_BLE_CENTRAL; CLX_BLE_PERIPHERAL; __CLX_BLE_ISOCHRONOUS; __CLX_WIFI_MESH_AUTO; __CLARINOX_WLAN_MESH_TOPOLOGY_TREE_SUPPORTED; CLX_BLE_HIGH_QUALITY_AUDIO; __CLX_BANDWIDTH_LIMIT_SUPPORTED; __CLARINOX_MESH_DEMO_ROOT_MENU; __CLARINOX_MESH_DEMO_NONROOT_MENU; USE_CLARINOX_POOLSET
  ICCARM.IExtraOptions: --preinclude source/mcux_config.h --preinclude source/mcuxsdk_version.h --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: source/wifi_config.h
  ICCARM.CCIncludePath2: source; board; flash_config; framework; framework/Platform; framework/Platform/configs; drivers; CMSIS/Core/Include; CMSIS/Core/Include/m-profile; device; device/periph; utilities/debug_console; component/lists; utilities/str; component/serial_manager; component/uart; component/imu_adapter; component/osa; component/wifi_bt_module/AzureWave/tx_pwr_limits; component/wifi_bt_module/Murata/tx_pwr_limits; component/wifi_bt_module/u-blox/tx_pwr_limits; component/wifi_bt_module/incl; component/els_pkc; component/els_pkc/src/comps/mcuxClBuffer/inc; component/els_pkc/src/comps/mcuxClBuffer/inc/internal; component/els_pkc/src/comps/mcuxClCore/inc; component/els_pkc/src/comps/mcuxClEls/inc; component/els_pkc/src/comps/mcuxClEls/inc/internal; component/els_pkc/src/comps/mcuxClMemory/inc; component/els_pkc/src/comps/mcuxClMemory/inc/internal; component/els_pkc/src/comps/mcuxCsslMemory/inc; component/els_pkc/src/comps/mcuxCsslMemory/inc/internal; component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; component/els_pkc/src/comps/mcuxCsslFlowProtection/inc; component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; component/els_pkc/src/comps/mcuxCsslSecureCounter/inc; component/els_pkc/src/compiler; component/els_pkc/src/platforms/rw61x; component/els_pkc/src/platforms/rw61x/inc; component/els_pkc/includes/platform/rw61x; component/power_manager/core; component/power_manager/devices/RW612; flash/mflash; flash/mflash/frdmrw612; component/conn_fwloader/include; component/conn_fwloader/fw_bin; component/conn_fwloader/fw_bin/inc/rw61x; component/conn_fwloader/fw_bin/rw61x; component/conn_fwloader/fw_bin/inc/iw610x; component/conn_fwloader/fw_bin/iw610x; component/conn_fwloader/fw_bin/inc/8987; component/conn_fwloader/fw_bin/8987; component/conn_fwloader/fw_bin/inc/IW416; component/conn_fwloader/fw_bin/IW416; component/conn_fwloader/fw_bin/inc/nw61x; component/conn_fwloader/fw_bin/nw61x; component/conn_fwloader/fw_bin/script; freertos/freertos-kernel-upstream/include; freertos/freertos-kernel/include; freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure; Clarinox/Applications/KoalaApplication/Source; Clarinox/Applications/KoalaApplication/Source/WLAN; Clarinox/Applications/KoalaApplication/Source/Bluetooth; Clarinox/Applications/KoalaApplication/Source/Bluetooth/BLE; Clarinox/Applications/KoalaApplication/Source/Bluetooth/BLE/Central; Clarinox/Applications/KoalaApplication/Source/Bluetooth/BLE/Peripheral; Clarinox/System/CommonAPI; Clarinox/System/ClarinoxWLAN/API; Clarinox/System/ClarinoxBlue/API; Clarinox/System/BSP/Common; Clarinox/System/BSP/Boards/RW612; Clarinox/Applications/KoalaApplication/FreeRTOS/RW612/BSP; Clarinox/Lwip/Include; Clarinox/Lwip/lwip; Clarinox/Lwip/netif; Clarinox/Lwip/Port
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED
  AARM.AUserIncludes: as above
  AARM.PreInclude: source/mcux_config.h
  OBJCOPY.OOCOutputFile: clarinox_wifi_bluetooth.bin
  ILINK.IlinkOutputFile: clarinox_wifi_bluetooth.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: RW610_flash.icf
  ILINK.IlinkAdditionalLibs: component/conn_fwloader/fw_bin/lib/libcsi/cm33/iar/libcsi.a; Clarinox/Build/Lib/SoftFrame.a; Clarinox/Build/Lib/MLAN.a; Clarinox/Build/Lib/WLAN.a; Clarinox/Build/Lib/Bluetooth.a; Clarinox/Build/Lib/Wpa_Supplicant-2.11.a; Clarinox/Build/Lib/mbedtls-3.3.0.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_RTOS=1; CONFIG_MONOLITHIC_WIFI=0; PRINTF_ADVANCED_ENABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; CONFIG_WIFI_IND_DNLD=1; CONFIG_WIFI_IND_RESET=1; WIFI_BOARD_FRDM_RW61X; GENERIC_LIST_LIGHT=1; MFLASH_FILE_BASEADDR=7340032; CONFIG_NXP_WIFI_SOFTAP_SUPPORT=1; PRINTF_FLOAT_ENABLE=1; SO_REUSE=1; SDK_OS_FREE_RTOS; CLX_DEBUG; CLX_ARM; CLX_IAR; CLX_FREE_RTOS; CLX_LITTLE_ENDIAN; CLX_88W8977; CLX_64BIT_SUPPORT; __CLX_SOCKETS_SUPPORT; CLX_BSP_TEST=0; READ_ONLY_FILE_SUPPORTED; CLX_WPA_SUPPLICANT; CLX_WLAN_HOST_AP; CLX_IEEE802_11_N_SUPPORTED; CLX_IEEE802_11_R_SUPPORTED; CLX_USE_UART_FOR_CLARIFI_CONNECTION; __CLX_RW612_NXP_BOARD; __CLX_RW612_UBLOX_BOARD; CLX_RW612_FRDM_BOARD; __CLX_RW612_ISP_BOARD; __CLX_RW612_MURATA_BOARD; CLX_WLAN_VIRTUAL_AP_SUPPORTED; CLX_MARVELL; __CLARINOX_WLAN_MESH_SUPPORTED; CLX_NETWORK_INTERFACE_LWIP; CLX_ENABLE_BLUETOOTH; CLX_BLE_CENTRAL; CLX_BLE_PERIPHERAL; __CLX_BLE_ISOCHRONOUS; __CLX_WIFI_MESH_AUTO; __CLARINOX_WLAN_MESH_TOPOLOGY_TREE_SUPPORTED; CLX_BLE_HIGH_QUALITY_AUDIO; __CLX_BANDWIDTH_LIMIT_SUPPORTED; __CLARINOX_MESH_DEMO_ROOT_MENU; __CLARINOX_MESH_DEMO_NONROOT_MENU; USE_CLARINOX_POOLSET
  ICCARM.CCOptLevel: 3
  group board
    board/: board.c board.h clock_config.c clock_config.h
  group Clarinox/Applications/KoalaApplication/FreeRTOS/RW612/BSP
    Clarinox/Applications/KoalaApplication/FreeRTOS/RW612/BSP/: Bsp.c Bsp.h ClarinoxBlueDriver.Bsp.c ClxBlueConfig.c ClxBspConfig.h ClxBspConsole.c ClxBspFileList.c ClxBspHeap.c ClxBspInit.c ClxBspInit.h ClxBspThread.c ClxTrace.Bsp.c Imu_Bsp.c lowLevelUart.c NetworkBufferManager.Bsp.c
  group Clarinox/Applications/KoalaApplication/Source/Bluetooth
    Clarinox/Applications/KoalaApplication/Source/Bluetooth/: Gatt.cpp GattApp.h mainBleCentral.cpp mainBlePeripheral.cpp mainBluetooth.cpp mainBluetooth.h mainClassic.cpp ServiceVerbose.cpp ServiceVerbose.h
  group Clarinox/Applications/KoalaApplication/Source/Bluetooth/BLE
    Clarinox/Applications/KoalaApplication/Source/Bluetooth/BLE/: BleServiceCommon.h GapBle.cpp GapBleApp.h
  group Clarinox/Applications/KoalaApplication/Source/Bluetooth/BLE/Central
    Clarinox/Applications/KoalaApplication/Source/Bluetooth/BLE/Central/: GattClient.cpp GattClient.h
  group Clarinox/Applications/KoalaApplication/Source/Bluetooth/BLE/Peripheral
    Clarinox/Applications/KoalaApplication/Source/Bluetooth/BLE/Peripheral/: Gatt.Ble.Includes.cpp Gatt.Ble.Includes.h Gatt.custom_service.codec.cpp Gatt.custom_service.cpp Gatt.custom_service.h GattServer.cpp GattServer.h org.bluetooth.characteristic.gap.resolvable_private_address_only.codec.cpp org.bluetooth.characteristic.gap.resolvable_private_address_only.h org.bluetooth.service.alert_notification.codec.cpp org.bluetooth.service.alert_notification.cpp org.bluetooth.service.alert_notification.h org.bluetooth.service.battery_service.codec.cpp org.bluetooth.service.battery_service.cpp org.bluetooth.service.battery_service.h org.bluetooth.service.device_information.codec.cpp org.bluetooth.service.device_information.cpp org.bluetooth.service.device_information.h org.bluetooth.service.generic_access.codec.cpp org.bluetooth.service.generic_access.cpp org.bluetooth.service.generic_access.h org.bluetooth.service.generic_attribute.codec.cpp org.bluetooth.service.generic_attribute.cpp org.bluetooth.service.generic_attribute.h org.bluetooth.service.human_interface_device.cpp org.bluetooth.service.human_interface_device.h org.bluetooth.service.ranging_service.cpp org.bluetooth.service.ranging_service.h
  group Clarinox/Applications/KoalaApplication/Source/WLAN
    Clarinox/Applications/KoalaApplication/Source/WLAN/: lwipopts.h mainWiFi.c netconfig.h WiFiApp.h WlanBssInfoPrint.c WlanClient.c WlanScan.c WlanScan.h WlanServer.c wpa_supplicant.conf.h
  group Clarinox/Applications/KoalaApplication/Source/WLAN/Driver
    Clarinox/Applications/KoalaApplication/Source/WLAN/Driver/: Driver.h DriverMLAN.c
  group Clarinox/Lwip/Api
    Clarinox/Lwip/Api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Clarinox/Lwip/Core
    Clarinox/Lwip/Core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Clarinox/Lwip/Core/IPV4
    Clarinox/Lwip/Core/IPV4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Clarinox/Lwip/Include/compat/posix
    Clarinox/Lwip/Include/compat/posix/: netdb.h
  group Clarinox/Lwip/Include/compat/posix/arpa
    Clarinox/Lwip/Include/compat/posix/arpa/: inet.h
  group Clarinox/Lwip/Include/compat/posix/net
    Clarinox/Lwip/Include/compat/posix/net/: if.h
  group Clarinox/Lwip/Include/compat/posix/sys
    Clarinox/Lwip/Include/compat/posix/sys/: socket.h
  group Clarinox/Lwip/Include/compat/stdc
    Clarinox/Lwip/Include/compat/stdc/: errno.h
  group Clarinox/Lwip/Include/lwip
    Clarinox/Lwip/Include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h init.h.cmake.in ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group Clarinox/Lwip/Include/lwip/apps
    Clarinox/Lwip/Include/lwip/apps/: altcp_proxyconnect.h altcp_tls_mbedtls_opts.h FILES fs.h http_client.h httpd.h httpd_opts.h lwiperf.h mdns.h mdns_opts.h mdns_priv.h mqtt.h mqtt_opts.h mqtt_priv.h netbiosns.h netbiosns_opts.h smtp.h smtp_opts.h snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_snmpv2_framework.h snmp_snmpv2_usm.h snmp_table.h snmp_threadsync.h snmpv3.h sntp.h sntp_opts.h tftp_opts.h tftp_server.h
  group Clarinox/Lwip/Include/lwip/priv
    Clarinox/Lwip/Include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group Clarinox/Lwip/Include/lwip/prot
    Clarinox/Lwip/Include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group Clarinox/Lwip/Include/netif
    Clarinox/Lwip/Include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group Clarinox/Lwip/Include/netif/ppp
    Clarinox/Lwip/Include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group Clarinox/Lwip/Include/netif/ppp/polarssl
    Clarinox/Lwip/Include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group Clarinox/Lwip/Netif
    Clarinox/Lwip/Netif/: bridgeif.c bridgeif_fdb.c ethernet.c
  group Clarinox/Lwip/Port/arch
    Clarinox/Lwip/Port/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.h
  group Clarinox/Lwip/Port/ClxSoftFrame
    Clarinox/Lwip/Port/ClxSoftFrame/: sys_arch.c
  group Clarinox/System/BSP/Boards/RW612
    Clarinox/System/BSP/Boards/RW612/: HardwareBsp.c HardwareBsp.h HardwareUart.c HardwareWlan.c
  group Clarinox/System/BSP/JLink
    Clarinox/System/BSP/JLink/: JLinkRTT.DebugInterface.Bsp.c
  group Clarinox/System/BSP/JLink/JLinkRTT
    Clarinox/System/BSP/JLink/JLinkRTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group Clarinox/System/BSP/Network/LWIP
    Clarinox/System/BSP/Network/LWIP/: NetworkAccessInterface.LWIP_NOSYS.Bsp.c NetworkStackServiceInterface.LWIP.Bsp.c
  group Clarinox/System/BSP/OS/FreeRTOS/10_4_3
    Clarinox/System/BSP/OS/FreeRTOS/10_4_3/: BspOS.c
  group Clarinox/System/BSP/Source
    Clarinox/System/BSP/Source/: FileBsp.c UartBsp.c
  group CMSIS
    CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    CMSIS/Core/Include/m-profile/: armv8m_mpu.h cmsis_iccarm_m.h
  group component/conn_fwloader
    component/conn_fwloader/: fsl_loader.c fsl_loader_utils.c life_cycle.c nboot_hal.c readme.txt
  group component/conn_fwloader/fw_bin/inc/8987
    component/conn_fwloader/fw_bin/inc/8987/: sd8987_wlan.bin.inc sduart8987_wlan_bt.bin.inc uart8987_bt.bin.inc
  group component/conn_fwloader/fw_bin/inc/IW416
    component/conn_fwloader/fw_bin/inc/IW416/: sdIW416_wlan.bin.inc sduartIW416_wlan_bt.bin.inc uartIW416_bt.bin.inc
  group component/conn_fwloader/fw_bin/inc/iw610x
    component/conn_fwloader/fw_bin/inc/iw610x/: sd_iw610.bin.se.inc sd_iw610_compressed.bin.se.inc sduart_iw610.bin.se.inc sduart_iw610_compressed.bin.se.inc sduartspi_iw610.bin.se.inc sduartspi_iw610_compressed.bin.se.inc uart_iw610_bt.bin.se.inc uart_iw610_bt_compressed.bin.se.inc uartspi_iw610.bin.se.inc uartspi_iw610_compressed.bin.se.inc
  group component/conn_fwloader/fw_bin/inc/nw61x
    component/conn_fwloader/fw_bin/inc/nw61x/: sd_nw61x.bin.se.inc sduart_nw61x.bin.se.inc sduart_nw61x_zb_dual_pan.bin.se.inc uart_nw61x.bin.se.inc uart_nw61x_zb_dual_pan.bin.se.inc
  group component/conn_fwloader/fw_bin/inc/rw61x
    component/conn_fwloader/fw_bin/inc/rw61x/: rw61x_sb_ble_15d4_combo_a2.bin.inc rw61x_sb_ble_15d4_combo_a2_compressed.bin.inc rw61x_sb_ble_a2.bin.inc rw61x_sb_ble_a2_compressed.bin.inc rw61x_sb_wifi_a2.bin.inc rw61x_sb_wifi_a2_compressed.bin.inc
  group component/conn_fwloader/fw_bin/rw61x
    component/conn_fwloader/fw_bin/rw61x/: rw61x_cpu1.c rw61x_cpu2.c rw61x_sb_ble_15d4_combo_a2.bin rw61x_sb_ble_15d4_combo_a2_compressed.bin rw61x_sb_ble_a2.bin rw61x_sb_ble_a2_compressed.bin rw61x_sb_wifi_a2.bin rw61x_sb_wifi_a2_compressed.bin
  group component/conn_fwloader/fw_bin/script
    component/conn_fwloader/fw_bin/script/: wlan_gen_fw_incs.py
  group component/conn_fwloader/include
    component/conn_fwloader/include/: api_tree_root.h fsl_loader.h fsl_loader_utils.h fusemap.h life_cycle.h nboot_rom_api_table.h
  group component/devices/RW612
    component/power_manager/devices/RW612/: fsl_pm_device.c fsl_pm_device.h fsl_pm_device_config.h
  group component/els_pkc/includes
    component/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    component/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group component/els_pkc/src/compiler
    component/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    component/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    component/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/src
    component/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClCore/inc
    component/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    component/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Common.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_GlitchDetector.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_KeyManagement.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    component/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_Common.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClEls/src
    component/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    component/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    component/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxClMemory/src
    component/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    component/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    component/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    component/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    component/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    component/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    component/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/platforms/rw61x
    component/els_pkc/src/platforms/rw61x/: mcuxClConfig.h platform_specific_headers.h
  group component/els_pkc/src/platforms/rw61x/inc
    component/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/imu_adapter
    component/imu_adapter/: fsl_adapter_imu.c fsl_adapter_imu.h fsl_adapter_imu_common.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    component/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/power_manager
    component/power_manager/core/: fsl_pm_config.h fsl_pm_core.c fsl_pm_core.h
  group component/serial_manager
    component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    component/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    component/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/incl
    component/wifi_bt_module/incl/: wifi_bt_module_config.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    component/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2EL_WW.h wlan_txpwrlimit_cfg_murata_NH.h
  group component/wifi_bt_module/u-blox/tx_pwr_limits
    component/wifi_bt_module/u-blox/tx_pwr_limits/: wlan_txpwrlimit_cfg_jody_w5_WW.h
  group device
    device/: fsl_device_registers.h RW612.h RW612_COMMON.h RW612_features.h system_RW612.c system_RW612.h
  group device/periph
    device/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOC_OTP_CTRL.h PERI_SOCCIU.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group doc
    ../: examples_shared_readme.md README.md readme_modules.md wifi_examples_readme.md
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.c fsl_flexcomm.h fsl_flexspi.c fsl_flexspi.h fsl_gdma.c fsl_gdma.h fsl_gpio.c fsl_gpio.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_imu.c fsl_imu.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_rtc.c fsl_rtc.h fsl_usart.c fsl_usart.h
  group drivers/freertos
    drivers/freertos/: fsl_usart_freertos.c fsl_usart_freertos.h
  group flash/mflash
    flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/frdmrw612
    flash/mflash/frdmrw612/: mflash_drv.c mflash_drv.h
  group flash_config
    flash_config/: flash_config.c flash_config.h
  group framework/Platform
    framework/Platform/: fwk_platform.c fwk_platform.h fwk_platform_ble.c fwk_platform_ble.h fwk_platform_coex.c fwk_platform_coex.h fwk_platform_definitions.h fwk_platform_hdlc.c fwk_platform_ot.c fwk_platform_ot.h
  group framework/Platform/configs
    framework/Platform/configs/: fwk_config.h fwk_lfs_config.h fwk_platform_hdlc.h rw61x-mbedtls-config.h
  group freertos/freertos-kernel/include
    freertos/freertos-kernel/include/: freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/portable/MemMang
    freertos/freertos-kernel-upstream/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel-upstream
    freertos/freertos-kernel-upstream/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel-upstream/include
    freertos/freertos-kernel-upstream/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel-upstream/portable
    freertos/freertos-kernel-upstream/portable/: readme.txt
  group freertos/freertos-kernel-upstream/portable/MemMang
    freertos/freertos-kernel-upstream/portable/MemMang/: ReadMe.url
  group source
    source/: app.h FreeRTOSConfig.h FreeRTOSConfigBoard.h fsl_debug_console_conf.h fsl_os_abstraction_config.h hardware_init.c host_sleep.c host_sleep.h lpm.c lpm.h lwiphooks.h lwippools.h main.c mcux_config.h mcuxsdk_version.h pin_mux.c pin_mux.h wifi_bt_module_config.h wifi_config.h
  group startup/iar
    startup/iar/: startup_RW612.s
  group utilities
    utilities/debug_console/: fsl_assert.c fsl_assert.h
  group utilities/debug_console
    utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    utilities/str/: fsl_str.c fsl_str.h
